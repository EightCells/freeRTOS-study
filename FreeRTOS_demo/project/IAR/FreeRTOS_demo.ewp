# IAR project FreeRTOS_demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32F303xC GigaDevice GD32F303xC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32F30X_HD
  ICCARM.CCIncludePath2: ..\..\user; ..\..\core; ..\..\hardware\led; ..\..\hardware\time; ..\..\fwlib\Include; ..\..\freeRTOS\inc; ..\..\freeRTOS\port\MemMang; ..\..\freeRTOS\port\IAR\ARM_CM4F
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\user; ..\..\freeRTOS\inc; ..\..\freeRTOS\port\MemMang; ..\..\freeRTOS\port\IAR\ARM_CM4F
  ILINK.IlinkOutputFile: FreeRTOS_demo.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group core
    ../../core/: core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h startup_gd32f30x_hd.s
  group FreeRTOS/port
    ../../freeRTOS/port/IAR/ARM_CM4F/: port.c portasm.s
  group FreeRTOS/port/MemMang
    ../../freeRTOS/port/MemMang/: heap_4.c
  group FreeRTOS/src
    ../../freeRTOS/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group fwlib
    ../../fwlib/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_it.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c system_gd32f30x.c
  group hardware
    ../../hardware/led/: led.c
    ../../hardware/time/: timer.c
  group user
    ../../user/: FreeRTOSConfig.h main.c
